<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32F401RE_I2C.ewp</path>
    </project>
    <batchBuild />
</workspace>
