# IAR project STM32F401RE_I2C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ; CMSIS\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F401RE_I2C.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: delay.c delay.h EXTI.c EXTI.h gpio.c gpio.h i2c.c i2c.h LCD1602_I2C.c LCD1602_I2C.h main.c MPU6050.c MPU6050.h PID.c PID.h SET_CLOCK.c SET_CLOCK.h timer.c timers.h USART.c USART.h
  group CMSIS
    CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h core_cmFunc.h core_cmInstr.h mpu_armv7.h startup_stm32f401xe.s stm32f401xe.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
